# IAR project project.ewp, settings and files
configuration Debug (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; HC32F472; __DEBUG; __RTTHREAD__; USE_DDL_DRIVER; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCIncludePath2: ..\..\..\components\libc\posix\ipc; ..\platform\tca9539; ..\..\..\components\libc\posix\io\poll; ..\..\..\libcpu\arm\cortex-m4; ..\..\..\include; packages\hc32-f4-cmsis-latest\Include; board\ports; board\config; ..\..\..\components\libc\compilers\common\include; ..\..\..\components\finsh; ..\..\..\components\libc\posix\io\epoll; board\config\usb_config; ..\..\..\components\libc\posix\io\eventfd; ..\..\..\components\drivers\phy; .; ..\tests; ..\..\..\libcpu\arm\common; board; ..\..\..\components\libc\compilers\common\extension; ..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\components\drivers\smp_call; ..\..\..\components\drivers\include; ..\libraries\hc32_drivers; packages\hc32-f4-cmsis-latest\Device\HDSC\hc32f472\Include; applications; packages\hc32-f4-series-latest\hc32f472\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: rtthread.bin
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkConfigDefines: _LINK_FLASH_= 0; _HC32F472_512K_= 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group Applications
    applications/: main.c xtal32_fcm.c
  group Compiler
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/: board.c board_config.c
    ../libraries/hc32_drivers/: drv_common.c drv_gpio.c drv_i2c.c drv_irq.c drv_soft_i2c.c drv_usart.c
  group Finsh
    ../../../components/finsh/: cmd.c msh_parse.c msh.c shell.c
  group HC32F472-LL
    packages/hc32-f4-series-latest/hc32f472/src/: hc32_ll_utility.c hc32_ll_interrupts.c hc32_ll_gpio.c hc32_ll_rmu.c hc32_ll_tmr0.c hc32_ll_clk.c hc32_ll_fcg.c hc32_ll_usart.c hc32_ll_aos.c hc32_ll_i2c.c hc32_ll.c hc32_ll_dma.c hc32_ll_fcm.c hc32_ll_icg.c hc32_ll_efm.c hc32_ll_pwc.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../src/klibc/: rt_vsnprintf_tiny.c kerrno.c rt_vsscanf.c kstdio.c kstring.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group Libraries
    packages/hc32-f4-cmsis-latest/Device/HDSC/hc32f472/Source/IAR/: startup_hc32f472.s
    packages/hc32-f4-cmsis-latest/Device/HDSC/hc32f472/Source/: system_hc32f472.c
  group Platform
    ../platform/tca9539/: tca9539.c
  group Tests
    ../tests/: test_uart_v1.c test_gpio.c test_i2c.c test_soft_i2c.c
